# Repository WestianPKl/pcb-docs (continued)

## KiCad design Micro_DAQ/Output_Board/output_board.kicad_pcb

Parts:
C1: 4.7uF; C_0603_1608Metric
C2, C3, C4, C5, C6, C9, C10: 100nF; C_0603_1608Metric
C19: 2.2uF; C_0603_1608Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12: SMAJ36CA; D_SMA
F1, F2, F3, F4, F5, F6, F7, F8, F9, F10, F11, F12: MF-MSMF030/60; Fuse_1812_4532Metric
IC1: STM32C562CET6; QFP50P900X900X160-48N; Manufacturer_Part_Number STM32C562CET6
IC2: MCP2562FD-E_SN; SOIC127P600X175-8N; Manufacturer_Part_Number MCP2562FD-E/SN; Mouser Part Number 579-MCP2562FD-E/SN
IC3, IC4: ULN2803ADW; SOIC127P1030X265-18N; Manufacturer_Part_Number ULN2803ADW; Mouser Part Number 595-ULN2803ADW
IC5, IC6, IC7, IC8, IC9, IC10, IC11, IC12, IC13, IC14, IC15, IC16: AQY-212EHAT; SOP254P962X315-4N; Manufacturer_Part_Number AQY-212EHAT
J2: PWR; PinSocket_2x15_P2.54mm_Vertical
J3: LED; PinSocket_2x04_P2.54mm_Vertical
J4: JTAG; PinHeader_2x05_P1.27mm_Vertical
J5: DS1037-37FNAKT74-0CC; DS103737FNAKT740CC; Manufacturer_Part_Number DS1037-37FNAKT74-0CC
R1, R2, R3: 1kR; R_0603_1608Metric
R4: 3k3R; R_0603_1608Metric
R5, R6, R7: 10kR; R_0603_1608Metric
R8, R9, R10, R11: 4k7R; R_0603_1608Metric
R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23: 270R; R_0603_1608Metric

Connections:
+3.3V_AUX: C1.1, C2.1, C3.1, C4.1, C6.1, C10.2, IC1.9 (VREF+), IC1.24 (VDD_1), IC1.36 (VDD_2), IC1.48 (VDD_3), IC2.5 (VIO), J2.14, J2.16, J4.1 (VTref), R5.1, R8.1, R9.1, R10.1, R11.1, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2
+5V: C9.2, IC2.3 (VDD), J2.10, J2.12
+12V: J2.2, J2.4, J2.6, J2.8
/BOOT0: IC1.44 (PH2-BOOT0), R6.1
/CAN1_H: IC2.7 (CANH), J2.25
/CAN1_L: IC2.6 (CANL), J2.27
/FAULT: IC1.27 (PB14), J2.26
/FDCAN1_RX: IC1.32 (PA11), IC2.4 (RXD)
/FDCAN1_TX: IC1.33 (PA12), IC2.1 (TXD)
/LED1: IC1.10 (PA0), J3.3
/LED2: IC1.11 (PA1), J3.7
/LED3: IC1.12 (PA2), J3.8
/LED4: IC1.13 (PA3), J3.4
/NRST: C5.2, IC1.7 (NRST), J2.24, J4.10 (~RESET), R5.2
/OUT_0: F1.1, J5.2
/OUT_1: F2.1, J5.4
/OUT_2: F3.1, J5.6
/OUT_3: F4.1, J5.8
/OUT_4: F5.1, J5.10
/OUT_5: F6.1, J5.12
/OUT_6: F7.1, J5.14
/OUT_7: F8.1, J5.16
/OUT_8: F9.1, J5.18
/OUT_9: F10.1, J5.20
/OUT_10: F11.1, J5.22
/OUT_11: F12.1, J5.24
/OUT_COM_0: D1.2 (A2), IC5.4 (D_2), J5.1
/OUT_COM_1: D2.2 (A2), IC6.4 (D_2), J5.3
/OUT_COM_2: D3.2 (A2), IC7.4 (D_2), J5.5
/OUT_COM_3: D4.2 (A2), IC8.4 (D_2), J5.7
/OUT_COM_4: D5.2 (A2), IC9.4 (D_2), J5.9
/OUT_COM_5: D6.2 (A2), IC10.4 (D_2), J5.11
/OUT_COM_6: D12.2 (A2), IC11.4 (D_2), J5.13
/OUT_COM_7: D11.2 (A2), IC12.4 (D_2), J5.15
/OUT_COM_8: D10.2 (A2), IC13.4 (D_2), J5.17
/OUT_COM_9: D9.2 (A2), IC14.4 (D_2), J5.19
/OUT_COM_10: D8.2 (A2), IC15.4 (D_2), J5.21
/OUT_COM_11: D7.2 (A2), IC16.4 (D_2), J5.23
/OUT_MCU_0: IC1.14 (PA4), IC3.1 (1B)
/OUT_MCU_1: IC1.15 (PA5), IC3.2 (2B)
/OUT_MCU_2: IC1.16 (PA6), IC3.3 (3B)
/OUT_MCU_3: IC1.17 (PA7), IC3.4 (4B)
/OUT_MCU_4: IC1.18 (PB0), IC3.5 (5B)
/OUT_MCU_5: IC1.19 (PB1), IC3.6 (6B)
/OUT_MCU_6: IC1.20 (PB2), IC3.7 (7B)
/OUT_MCU_7: IC1.39 (PB3), IC3.8 (8B)
/OUT_MCU_8: IC1.43 (PB7), IC4.1 (1B)
/OUT_MCU_9: IC1.42 (PB6), IC4.2 (2B)
/OUT_MCU_10: IC1.41 (PB5), IC4.3 (3B)
/OUT_MCU_11: IC1.40 (PB4), IC4.4 (4B)
/OUT_MCU_PWM_12: IC1.29 (PA8), IC4.5 (5B)
/OUT_MCU_PWM_13: IC1.30 (PA9), IC4.6 (6B)
/OUT_MCU_PWM_14: IC1.31 (PA10), IC4.7 (7B)
/OUT_MCU_PWM_15: IC1.38 (PA15), IC4.8 (8B)
/OUT_ULN_0: IC3.18 (1C), IC5.2 (K)
/OUT_ULN_1: IC3.17 (2C), IC6.2 (K)
/OUT_ULN_2: IC3.16 (3C), IC7.2 (K)
/OUT_ULN_3: IC3.15 (4C), IC8.2 (K)
/OUT_ULN_4: IC3.14 (5C), IC9.2 (K)
/OUT_ULN_5: IC3.13 (6C), IC10.2 (K)
/OUT_ULN_6: IC3.12 (7C), IC11.2 (K)
/OUT_ULN_7: IC3.11 (8C), IC12.2 (K)
/OUT_ULN_8: IC4.18 (1C), IC13.2 (K)
/OUT_ULN_9: IC4.17 (2C), IC14.2 (K)
/OUT_ULN_10: IC4.16 (3C), IC15.2 (K)
/OUT_ULN_11: IC4.15 (4C), IC16.2 (K)
/OUT_ULN_PWM_12: IC4.14 (5C), J5.26, R8.2
/OUT_ULN_PWM_13: IC4.13 (6C), J5.28, R9.2
/OUT_ULN_PWM_14: IC4.12 (7C), J5.30, R10.2
/OUT_ULN_PWM_15: IC4.11 (8C), J5.32, R11.2
/PB9: IC1.46 (PB9)
/PB10: IC1.21 (PB10)
/PC13: IC1.2 (PC13)
/PC14: IC1.3 (PC14-OSC32_IN)
/PC15: IC1.4 (PC15-OSC32_OUT)
/PE2: IC1.1 (PE2)
/PH0: IC1.5 (PH0-OSC_IN)
/PH1: IC1.6 (PH1-OSC_OUT)
/RES0_0: J2.17
/RES1_0: J2.19
/RES2_0: J2.21
/RES3_0: J2.18
/RES4_0: J2.20
/RES5_0: J2.22
/SLOT_ID0: IC1.25 (PB12), J2.30
/SLOT_ID1: IC1.26 (PB13), J2.29
/STBY: IC1.45 (PB8), IC2.8 (STBY), R7.1
/SWCLK: IC1.37 (PA14), J4.4 (SWCLK/TCK)
/SWDIO: IC1.34 (PA13), J4.2 (SWDIO/TMS)
/SYNC: IC1.28 (PB15), J2.23
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.2, C9.1, C10.1, C19.1, IC1.8 (VREF-), IC1.23 (VSS_1), IC1.35 (VSS_2), IC1.47 (VSS_3), IC2.2 (VSS), IC3.9 (GND), IC4.9 (GND), J2.1, J2.3, J2.5, J2.7, J2.9, J2.11, J2.13, J2.15, J2.28, J4.3 (GND), J4.5 (GND), J4.9 (GNDDetect), J5.25, J5.27, J5.29, J5.31, J5.MH1, J5.MH2, R1.2, R2.2, R3.2, R4.2, R6.2, R7.2
unnamed: D1.1 (A1), F1.2, IC5.3 (D_1)
unnamed: D2.1 (A1), F2.2, IC6.3 (D_1)
unnamed: D3.1 (A1), F3.2, IC7.3 (D_1)
unnamed: D4.1 (A1), F4.2, IC8.3 (D_1)
unnamed: D5.1 (A1), F5.2, IC9.3 (D_1)
unnamed: D6.1 (A1), F6.2, IC10.3 (D_1)
unnamed: D7.1 (A1), F12.2, IC16.3 (D_1)
unnamed: D8.1 (A1), F11.2, IC15.3 (D_1)
unnamed: D9.1 (A1), F10.2, IC14.3 (D_1)
unnamed: D10.1 (A1), F9.2, IC13.3 (D_1)
unnamed: D11.1 (A1), F8.2, IC12.3 (D_1)
unnamed: D12.1 (A1), F7.2, IC11.3 (D_1)
unnamed: C19.2, IC1.22 (VCAP)
unnamed: IC5.1 (A), R12.1
unnamed: IC6.1 (A), R13.1
unnamed: IC7.1 (A), R14.1
unnamed: IC8.1 (A), R15.1
unnamed: IC9.1 (A), R16.1
unnamed: IC10.1 (A), R17.1
unnamed: IC11.1 (A), R18.1
unnamed: IC12.1 (A), R19.1
unnamed: IC13.1 (A), R20.1
unnamed: IC14.1 (A), R21.1
unnamed: IC15.1 (A), R22.1
unnamed: IC16.1 (A), R23.1
unnamed: J3.1, R1.1
unnamed: J3.2, R4.1
unnamed: J3.5, R2.1
unnamed: J3.6, R3.1

Board: 2 copper layers, 100.0 x 80.0 mm, 76 parts (0 on the bottom side), 106 nets.

## KiCad design Micro_DAQ/Switch_Board/switch_board.kicad_pcb

Parts:
C1: 4.7uF; C_0603_1608Metric
C2, C3, C4, C5, C6, C7, C8, C9, C10: 100nF; C_0603_1608Metric
C11: 100uF; CP_Elec_6.3x7.7
C19: 2.2uF; C_0603_1608Metric
IC1: STM32C562CET6; QFP50P900X900X160-48N; Manufacturer_Part_Number STM32C562CET6
IC2: MCP2562FD-E_SN; SOIC127P600X175-8N; Manufacturer_Part_Number MCP2562FD-E/SN; Mouser Part Number 579-MCP2562FD-E/SN
J2: PWR; PinSocket_2x15_P2.54mm_Vertical
J3: LED; PinSocket_2x04_P2.54mm_Vertical
J4: JTAG; PinHeader_2x05_P1.27mm_Vertical
J5: DS1037-37FNAKT74-0CC; DS103737FNAKT740CC; Manufacturer_Part_Number DS1037-37FNAKT74-0CC
K1, K2, K3, K4, K5, K6, K7, K8, K9, K10, K11, K12: AZ6991-1C-12DE; AZ69911C12DE; Manufacturer_Part_Number AZ6991-1C-12DE
Q1, Q2: TBD62083AFWG; SOIC127P1032X285-18N; Manufacturer_Part_Number TBD62083AFWG; Mouser Part Number 757-TBD62083AFWG
R1, R2, R3: 1kR; R_0603_1608Metric
R4: 3k3R; R_0603_1608Metric
R5, R6, R7: 10kR; R_0603_1608Metric

Connections:
+3.3V_AUX: C1.1, C2.1, C3.1, C4.1, C6.1, C10.2, IC1.9 (VREF+), IC1.24 (VDD_1), IC1.36 (VDD_2), IC1.48 (VDD_3), IC2.5 (VIO), J2.14, J2.16, J4.1 (VTref), R5.1
+5V: C9.2, IC2.3 (VDD), J2.10, J2.12
+12V: C7.2, C8.2, C11.1, J2.2, J2.4, J2.6, J2.8, K1.1 (COIL_1), K2.1 (COIL_1), K3.1 (COIL_1), K4.1 (COIL_1), K5.1 (COIL_1), K6.1 (COIL_1), K7.1 (COIL_1), K8.1 (COIL_1), K9.1 (COIL_1), K10.1 (COIL_1), K11.1 (COIL_1), K12.1 (COIL_1), Q1.10 (COMMON), Q2.10 (COMMON)
/BOOT0: IC1.44 (PH2-BOOT0), R6.1
/CAN1_H: IC2.7 (CANH), J2.25
/CAN1_L: IC2.6 (CANL), J2.27
/COM0: J5.3, K1.4 (COM)
/COM1: J5.6, K2.4 (COM)
/COM2: J5.9, K3.4 (COM)
/COM3: J5.12, K4.4 (COM)
/COM4: J5.15, K5.4 (COM)
/COM5: J5.18, K6.4 (COM)
/COM6: J5.37, K7.4 (COM)
/COM7: J5.22, K8.4 (COM)
/COM8: J5.25, K9.4 (COM)
/COM9: J5.28, K10.4 (COM)
/COM10: J5.31, K11.4 (COM)
/COM11: J5.34, K12.4 (COM)
/FAULT: IC1.27 (PB14), J2.26
/FDCAN1_RX: IC1.32 (PA11), IC2.4 (RXD)
/FDCAN1_TX: IC1.33 (PA12), IC2.1 (TXD)
/LED1: IC1.10 (PA0), J3.3
/LED2: IC1.11 (PA1), J3.7
/LED3: IC1.12 (PA2), J3.8
/LED4: IC1.13 (PA3), J3.4
/NC0: J5.1, K1.3 (N.C.)
/NC1: J5.4, K2.3 (N.C.)
/NC2: J5.7, K3.3 (N.C.)
/NC3: J5.10, K4.3 (N.C.)
/NC4: J5.13, K5.3 (N.C.)
/NC5: J5.16, K6.3 (N.C.)
/NC6: J5.19, K7.3 (N.C.)
/NC7: J5.20, K8.3 (N.C.)
/NC8: J5.23, K9.3 (N.C.)
/NC9: J5.26, K10.3 (N.C.)
/NC10: J5.29, K11.3 (N.C.)
/NC11: J5.32, K12.3 (N.C.)
/NO0: J5.2, K1.5 (N.O.)
/NO1: J5.5, K2.5 (N.O.)
/NO2: J5.8, K3.5 (N.O.)
/NO3: J5.11, K4.5 (N.O.)
/NO4: J5.14, K5.5 (N.O.)
/NO5: J5.17, K6.5 (N.O.)
/NO6: J5.36, K7.5 (N.O.)
/NO7: J5.21, K8.5 (N.O.)
/NO8: J5.24, K9.5 (N.O.)
/NO9: J5.27, K10.5 (N.O.)
/NO10: J5.30, K11.5 (N.O.)
/NO11: J5.33, K12.5 (N.O.)
/NRST: C5.2, IC1.7 (NRST), J2.24, J4.10 (~RESET), R5.2
/PA9: IC1.30 (PA9)
/PA10: IC1.31 (PA10)
/PA15: IC1.38 (PA15)
/PB9: IC1.46 (PB9)
/PB10: IC1.21 (PB10)
/PB15: IC1.28 (PB15)
/PC13: IC1.2 (PC13)
/PC14: IC1.3 (PC14-OSC32_IN)
/PC15: IC1.4 (PC15-OSC32_OUT)
/PE2: IC1.1 (PE2)
/PH0: IC1.5 (PH0-OSC_IN)
/PH1: IC1.6 (PH1-OSC_OUT)
/REL0: IC1.14 (PA4), Q1.1 (I1)
/REL1: IC1.15 (PA5), Q1.2 (I2)
/REL2: IC1.16 (PA6), Q1.3 (I3)
/REL3: IC1.17 (PA7), Q1.4 (I4)
/REL4: IC1.18 (PB0), Q1.5 (I5)
/REL5: IC1.19 (PB1), Q1.6 (I6)
/REL6: IC1.20 (PB2), Q1.7 (I7)
/REL7: IC1.39 (PB3), Q1.8 (I8)
/REL8: IC1.40 (PB4), Q2.1 (I1)
/REL9: IC1.41 (PB5), Q2.2 (I2)
/REL10: IC1.42 (PB6), Q2.3 (I3)
/REL11: IC1.43 (PB7), Q2.4 (I4)
/REL_L0: K1.2 (COIL_2), Q1.18 (O1)
/REL_L1: K2.2 (COIL_2), Q1.17 (O2)
/REL_L2: K3.2 (COIL_2), Q1.16 (O3)
/REL_L3: K4.2 (COIL_2), Q1.15 (O4)
/REL_L4: K5.2 (COIL_2), Q1.14 (O5)
/REL_L5: K6.2 (COIL_2), Q1.13 (O6)
/REL_L6: K7.2 (COIL_2), Q1.12 (O7)
/REL_L7: K8.2 (COIL_2), Q1.11 (O8)
/REL_L8: K9.2 (COIL_2), Q2.18 (O1)
/REL_L9: K10.2 (COIL_2), Q2.17 (O2)
/REL_L10: K11.2 (COIL_2), Q2.16 (O3)
/REL_L11: K12.2 (COIL_2), Q2.15 (O4)
/RES0_0: J2.17
/RES1_0: J2.19
/RES2_0: J2.21
/RES3_0: J2.18
/RES4_0: J2.20
/RES5_0: J2.22
/SLOT_ID0: IC1.25 (PB12), J2.30
/SLOT_ID1: IC1.26 (PB13), J2.29
/STBY: IC1.45 (PB8), IC2.8 (STBY), R7.1
/SWCLK: IC1.37 (PA14), J4.4 (SWCLK/TCK)
/SWDIO: IC1.34 (PA13), J4.2 (SWDIO/TMS)
/SYNC: IC1.29 (PA8), J2.23
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.2, C7.1, C8.1, C9.1, C10.1, C11.2, C19.1, IC1.8 (VREF-), IC1.23 (VSS_1), IC1.35 (VSS_2), IC1.47 (VSS_3), IC2.2 (VSS), J2.1, J2.3, J2.5, J2.7, J2.9, J2.11, J2.13, J2.15, J2.28, J4.3 (GND), J4.5 (GND), J4.9 (GNDDetect), J5.MH1, J5.MH2, Q1.9 (GND), Q2.5 (I5), Q2.6 (I6), Q2.7 (I7), Q2.8 (I8), Q2.9 (GND), R1.2, R2.2, R3.2, R4.2, R6.2, R7.2
unnamed: C19.2, IC1.22 (VCAP)
unnamed: J3.1, R1.1
unnamed: J3.2, R4.1
unnamed: J3.5, R2.1
unnamed: J3.6, R3.1

Board: 2 copper layers, 100.0 x 80.0 mm, 39 parts (0 on the bottom side), 86 nets.

## KiCad design Micro_DAQ/Backplane/backplane.kicad_pcb

Parts:
C1: 4.7nF; C_0603_1608Metric
H1, H2, H3, H4, H5, H6: MountingHole_Pad; MountingHole_3.2mm_M3_ISO14580_Pad_TopBottom
J1: CONTROLLER; PinSocket_2x15_P2.54mm_Vertical
J2: PWR; PinSocket_2x15_P2.54mm_Vertical
J3: SLOT_ID0; PinSocket_2x15_P2.54mm_Vertical
J4: SLOT_ID1; PinSocket_2x15_P2.54mm_Vertical
J5: SLOT_ID2; PinSocket_2x15_P2.54mm_Vertical
JP1: Jumper_2_Bridged; PinHeader_1x02_P2.54mm_Vertical
R1, R2: 60R; R_0603_1608Metric
R3, R4, R5, R6, R7, R8, R9, R10, R11: 4k7R; R_0603_1608Metric
R30: 120R; R_0603_1608Metric

Connections:
+3.3V_AUX: J1.5, J1.7, J2.23, J2.25, J2.27, J2.29, J3.13, J3.15, J4.13, J4.15, J5.13, J5.15, R3.2, R6.2, R7.2, R9.2, R11.2
+5V: J1.1, J1.3, J2.15, J2.17, J2.19, J2.21, J3.9, J3.11, J4.9, J4.11, J5.9, J5.11
+12V: J2.1, J2.3, J2.5, J2.7, J2.9, J2.11, J2.13, J3.1, J3.3, J3.5, J3.7, J4.1, J4.3, J4.5, J4.7, J5.1, J5.3, J5.5, J5.7
/CAN1_H: J1.28, J3.26, J4.26, J5.26, R1.1, R30.1
/CAN1_L: J1.30, J3.28, J4.28, J5.28, JP1.2 (B), R2.2
/CARD_DET0: J1.13, J3.27, R3.1
/CARD_DET1: J1.19, J4.27, R6.1
/CARD_DET2: J1.25, J5.27, R9.1
/CTRL_RX: J1.24, J2.30
/CTRL_TX: J1.22, J2.28
/FAULT_0: J1.15, J3.25
/FAULT_1: J1.21, J4.25
/FAULT_2: J1.27, J5.25
/FAULT_PWR: J1.9, J2.26
/RES0_0: J3.18
/RES0_1: J4.18
/RES0_2: J5.18
/RES1_0: J3.20
/RES1_1: J4.20
/RES1_2: J5.20
/RES2_0: J3.22
/RES2_1: J4.22
/RES2_2: J5.22
/RES3_0: J3.17
/RES3_1: J4.17
/RES3_2: J5.17
/RES4_0: J3.19
/RES4_1: J4.19
/RES4_2: J5.19
/RES5_0: J3.21
/RES5_1: J4.21
/RES5_2: J5.21
/RESC_0: J1.10
/RESC_1: J1.12
/RESC_2: J1.14
/RESC_3: J1.16
/RESC_4: J1.18
/RESC_5: J1.20
/RESC_6: J1.11
/RESET_N0: J1.17, J3.23
/RESET_N1: J1.23, J4.23
/RESET_N2: J1.29, J5.23
/SLOT0_ID0: J3.29, R4.1
/SLOT0_ID1: J3.30, R5.1
/SLOT1_ID0: J4.29, R7.1
/SLOT1_ID1: J4.30, R8.1
/SLOT2_ID0: J5.29, R10.1
/SLOT2_ID1: J5.30, R11.1
/SYNC: J1.26, J3.24, J4.24, J5.24
GND: C1.1, H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), H4.1 (1_1), H5.1 (1_1), H6.1 (1_1), J1.2, J1.4, J1.6, J1.8, J2.2, J2.4, J2.6, J2.8, J2.10, J2.12, J2.14, J2.16, J2.18, J2.20, J2.22, J2.24, J3.2, J3.4, J3.6, J3.8, J3.10, J3.12, J3.14, J3.16, J4.2, J4.4, J4.6, J4.8, J4.10, J4.12, J4.14, J4.16, J5.2, J5.4, J5.6, J5.8, J5.10, J5.12, J5.14, J5.16, R4.2, R5.2, R8.2, R10.2
unnamed: C1.2, R1.2, R2.1
unnamed: JP1.1 (A), R30.2

Notes on the sheet:
CTRL
EXTENSION
PWR

Board: 2 copper layers, 160.0 x 62.0 mm, 25 parts (0 on the bottom side), 27 nets.
