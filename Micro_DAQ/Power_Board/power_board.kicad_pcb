# Repository WestianPKl/pcb-docs (continued)

## KiCad design Micro_DAQ/Test_Board/test_board.kicad_pcb

Parts:
C1: 4.7uF; C_0603_1608Metric
C2, C3, C4, C5, C6, C9, C10, C11, C12, C17, C18, C21, C23: 100nF; C_0603_1608Metric
C7: 100nF; C_1206_3216Metric
C8: 10uF; CP_Elec_6.3x5.8
C13, C16, C20, C22: 10uF; C_0805_2012Metric
C14, C15: 12pF; C_0603_1608Metric
C19: 2.2uF; C_0603_1608Metric
D1: BZT52C15-DIO; D_SOD-123F
D2: SS54BF-DC; D_SMB
D3: SMBJ18A-LF; D_SMB
D4, D5: LED; LED_0603_1608Metric
D6: ESDCAN04; SOT-23
F1: TR1-2410TD5-R; FUSC6127X287N; Manufacturer_Part_Number TR1-2410TD5-R; Mouser Part Number 504-TR1-2410TD5-R
IC1: STM32C542CC; QFP50P900X900X160-48N; Manufacturer_Part_Number STM32C562CET6
IC2: MCP2562FD-E_SN; SOIC127P600X175-8N; Manufacturer_Part_Number MCP2562FD-E/SN; Mouser Part Number 579-MCP2562FD-E/SN
IC3: TC4420EOA; SOIC127P600X175-8N; Manufacturer_Part_Number TC4420EOA; Mouser Part Number 579-TC4420EOA
J2: BULB; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
J3: PWR; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
J4: JTAG; PinHeader_2x05_P1.27mm_Vertical
J5: ARK KF301 raster 5.0mm 3 pin; TerminalBlock_Phoenix_MKDS-1,5-3_1x03_P5.00mm_Horizontal
Q1: AOD4184A; Manufacturer_Part_Number AOD4184A
Q2, Q3: 2N7002; SOT-23
R1: 100R; R_1206_3216Metric
R2: 47kR; R_1206_3216Metric
R3: 10R; R_1206_3216Metric
R4: 100kR; R_1206_3216Metric
R5, R6, R7, R16, R18, R19, R25: 10kR; R_0603_1608Metric
R8: 120R; R_0603_1608Metric
R9, R10: 2k2R; R_0603_1608Metric
R11: 56kR; R_0603_1608Metric
R12: 15kR; R_0603_1608Metric
R13: 82kR; R_0603_1608Metric
R14: 27kR; R_0603_1608Metric
R15, R17, R20, R23, R26: 100kR; R_0603_1608Metric
R21, R22: 100R; R_0603_1608Metric
R24: 1kR; R_0603_1608Metric
TP1: PWM_OUT; TestPoint_Pad_D1.0mm
TP2: GPIO_OUT; TestPoint_Pad_D1.0mm
TP3: DI_GND_IN; TestPoint_Pad_D1.0mm
TP5: DI_12V_IN; TestPoint_Pad_D1.0mm
TP6: DI_GND; TestPoint_Pad_D1.0mm
TP7, TP8, TP9, TP10, TP11: GND; TestPoint_Pad_D1.0mm
TP12, TP13, TP14, TP15, TP16: 12V; TestPoint_Pad_D1.0mm
TP17: INA-; TestPoint_Pad_D4.0mm
TP18: INA+; TestPoint_Pad_D4.0mm
TP19: DI_12V_OUT; TestPoint_Pad_D1.0mm
TP20: DI_GND_OUT; TestPoint_Pad_D1.0mm
TP21: 1kR_IN; TestPoint_Pad_D1.0mm
TP22: 10kR_IN; TestPoint_Pad_D1.0mm
TP23: 100kR_IN; TestPoint_Pad_D1.0mm
TP24: 1kR_OUT; TestPoint_Pad_D1.0mm
TP25: 10kR_OUT; TestPoint_Pad_D1.0mm
TP26: 100kR_OUT; TestPoint_Pad_D1.0mm
TP27: BULB_12V; TestPoint_Pad_D4.0mm
TP28: BULB_SW; TestPoint_Pad_D4.0mm
U1: LM1117MP-5.0; SOT-223-3_TabPin2
U2: LM1117MP-3.3; SOT-223-3_TabPin2
Y1: 3225-25M-SR; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V_AUX: C1.1, C2.1, C3.1, C4.1, C6.1, C10.2, C22.2, C23.2, IC1.9 (VREF+), IC1.24 (VDD_1), IC1.36 (VDD_2), IC1.48 (VDD_3), IC2.5 (VIO), J4.1 (VTref), R5.1, U2.2 (VO)
+5V: C9.2, C16.2, C17.2, C20.2, C21.2, IC2.3 (VDD), U1.2 (VO), U2.3 (VI)
+12V: F1.2, J3.1, TP18.1 (1_1), TP27.1 (1_1)
+12V_SEC: C7.1, C8.1, C13.2, C18.2, D2.1 (K), D3.1 (A1), D4.2 (A), D5.2 (A), IC3.1 (VDD_1), IC3.8 (VDD_2), R15.1, R19.1, TP12.1 (1_1), TP13.1 (1_1), TP14.1 (1_1), TP15.1 (1_1), TP16.1 (1_1), TP19.1 (1_1), TP24.1 (1_1), TP25.1 (1_1), TP26.1 (1_1), U1.3 (VI)
/ADC1_IN0: C12.2, IC1.10 (PA0), R15.2, R16.1
/ADC1_IN1: C11.2, IC1.11 (PA1), R17.2, R18.1
/BOOT0: IC1.44 (PH2-BOOT0), R6.1
/CAN1_H: D6.1 (A1), IC2.7 (CANH), J5.3, R8.2
/CAN1_L: D6.2 (A2), IC2.6 (CANL), J5.1, R8.1
/DAC1_OUT1: IC1.14 (PA4), TP6.1 (1_1)
/DI_IN0: IC1.12 (PA2), R13.2, R14.1
/DI_IN1: IC1.13 (PA3), R11.2, R12.1
/FDCAN1_RX: IC1.32 (PA11), IC2.4 (RXD)
/FDCAN1_TX: IC1.33 (PA12), IC2.1 (TXD)
/GPIO_OUT0: IC1.18 (PB0), R21.2
/NRST: C5.2, IC1.7 (NRST), J4.10 (~RESET), R5.2
/PA5: IC1.15 (PA5)
/PA6: IC1.16 (PA6)
/PA7: IC1.17 (PA7)
/PA10: IC1.31 (PA10)
/PA15: IC1.38 (PA15)
/PB1: IC1.19 (PB1)
/PB2: IC1.20 (PB2)
/PB3: IC1.39 (PB3)
/PB4: IC1.40 (PB4)
/PB5: IC1.41 (PB5)
/PB6: IC1.42 (PB6)
/PB7: IC1.43 (PB7)
/PB9: IC1.46 (PB9)
/PB10: IC1.21 (PB10)
/PB12: IC1.25 (PB12)
/PB13: IC1.26 (PB13)
/PB14: IC1.27 (PB14)
/PB15: IC1.28 (PB15)
/PC13: IC1.2 (PC13)
/PC14: IC1.3 (PC14-OSC32_IN)
/PC15: IC1.4 (PC15-OSC32_OUT)
/PE2: IC1.1 (PE2)
/PH0: C14.2, IC1.5 (PH0-OSC_IN), Y1.3
/PH1: C15.2, IC1.6 (PH1-OSC_OUT), Y1.1
/STBY: IC1.45 (PB8), IC2.8 (STBY), R7.1
/SWCLK: IC1.37 (PA14), J4.4 (SWCLK/TCK)
/SWDIO: IC1.34 (PA13), J4.2 (SWDIO/TMS)
/TIM1_CH1: IC1.29 (PA8), R1.1
/TIM1_CH2: IC1.30 (PA9), R22.2
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.2, C7.2, C8.2, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, D1.2 (A), D3.2 (A2), D6.3 (common), IC1.8 (VREF-), IC1.23 (VSS_1), IC1.35 (VSS_2), IC1.47 (VSS_3), IC2.2 (VSS), IC3.4 (GND_1), IC3.5 (GND_2), J3.2, J4.3 (GND), J4.5 (GND), J4.9 (GNDDetect), J5.2, Q1.3 (S), Q2.2 (S), Q3.2 (S), R2.2, R4.2, R6.2, R7.2, R12.2, R14.2, R16.2, R18.2, R20.2, R23.2, TP7.1 (1_1), TP8.1 (1_1), TP9.1 (1_1), TP10.1 (1_1), TP11.1 (1_1), TP20.1 (1_1), U1.1 (GND), U2.1 (GND)
unnamed: D1.1 (K), Q1.1 (G), R3.2, R4.1
unnamed: D2.2 (A), TP17.1 (1_1)
unnamed: D4.1 (K), R9.1
unnamed: D5.1 (K), R10.1
unnamed: C19.2, IC1.22 (VCAP)
unnamed: IC3.2 (INPUT), R1.2, R2.1
unnamed: IC3.6 (OUTPUT_1), IC3.7 (OUTPUT_2), R3.1
unnamed: J2.1, Q1.2 (D), TP28.1 (1_1)
unnamed: F1.1, J2.2
unnamed: Q2.3 (D), R9.2, TP2.1 (1_1)
unnamed: Q2.1 (G), R20.1, R21.1
unnamed: Q3.3 (D), R10.2, TP1.1 (1_1)
unnamed: Q3.1 (G), R22.1, R23.1
unnamed: R11.1, TP5.1 (1_1)
unnamed: R13.1, R19.2, TP3.1 (1_1)
unnamed: R17.1, R24.2, R25.2, R26.2
unnamed: R24.1, TP21.1 (1_1)
unnamed: R25.1, TP22.1 (1_1)
unnamed: R26.1, TP23.1 (1_1)

Board: 2 copper layers, 65.2 x 80.0 mm, 96 parts (0 on the bottom side), 43 nets.

## KiCad design Supply_Board/Supply_Board.kicad_pcb

Parts:
C1: 10uF; C_0603_1608Metric
C2: 100nF; C_0603_1608Metric
C3: 10uF; C_1206_3216Metric
C4: 100nF; C_0805_2012Metric
C5: 100pF; C_0805_2012Metric
C6, C7: 22uF; C_1206_3216Metric
D1: SMF5.0A; D_SOD-123F
F1: 1A; Fuse_1206_3216Metric
FB1: CBM04YTAG601; L_1206_3216Metric
J1: USB_B_Micro; USB_Micro-B_Molex-105017-0001
J2, J3, J4: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
JP1, JP2: Jumper_2_Bridged; PinHeader_1x02_P2.54mm_Vertical
L1: DR73-6R8-R; L_7.3x7.3_H3.5
R1: 196kR; R_0805_2012Metric
R2: 62kR; R_0805_2012Metric
TP1: +5V; TestPoint_Pad_D1.5mm
TP2, TP6, TP7: GND; TestPoint_Pad_D1.5mm
TP3: FB; TestPoint_Pad_D1.5mm
TP4: SW; TestPoint_Pad_D1.5mm
TP5: +3.3V; TestPoint_Pad_D1.5mm
U1: AP63200WU; TSOT-23-6

Connections:
+3.3V: J3.1, J3.2, J3.3, J3.4, J3.5, JP2.2 (B), TP5.1 (1_1)
+5V: C3.1, FB1.1, J2.1, J2.2, J2.3, J2.4, J2.5, JP1.1 (A), TP1.1 (1_1)
GND: C1.1, C2.1, C3.2, C6.2, C7.2, D1.2 (A), J1.5 (GND), J1.SH (Shield), J4.1, J4.2, J4.3, J4.4, J4.5, R2.2, TP2.1 (1_1), TP6.1 (1_1), TP7.1 (1_1), U1.4 (GND)
unnamed: F1.1, FB1.2
unnamed: JP1.2 (B), U1.2 (EN), U1.3 (IN)
unnamed: C5.1, C6.1, C7.1, JP2.1 (A), L1.2, R1.1
unnamed: C4.2, U1.6 (BST)
unnamed: C5.2, R1.2, R2.1, TP3.1 (1_1), U1.1 (FB)
unnamed: C4.1, L1.1, TP4.1 (1_1), U1.5 (SW)
USB_VBUS: C1.2, C2.2, D1.1 (K), F1.2, J1.1 (VBUS)

Board: 2 copper layers, 34.6 x 30.3 mm, 27 parts (0 on the bottom side), 10 nets.

## Code that names these connections

File Tree_Board/TreeCode/main.c:

#ifndef F_CPU
#define F_CPU 1000000UL
#endif

#include <avr/io.h>
#include <avr/interrupt.h>
#include <stdint.h>

// PB0 - LED1 (OC0A)
// PB1 - LED2 (OC0B)
// PB2 - BUTTON (INT0)
#define LED1 (1 << PB0)
#define LED2 (1 << PB1)
#define BUTTON_1 (1 << PB2)

volatile uint8_t mode_selector = 0;
volatile uint8_t mode_changed = 1;
volatile uint16_t millis_counter = 0;
volatile uint8_t debounce_counter = 0;

volatile uint8_t blink_state = 0;
volatile uint16_t blink_timer = 0;

volatile uint8_t pwm_duty = 0;
volatile int8_t pwm_direction = 1;
volatile uint8_t pwm_timer = 0;

void pwm_init(void);
void pwm_disable(void);
void timer1_init(void);
void pwm_setDutyCycle(uint8_t duty_led1, uint8_t duty_led2);

ISR(TIMER1_COMPA_vect)
{
    millis_counter++;
    
    if (debounce_counter > 0) {
        debounce_counter--;
    }

    if (blink_timer > 0) {
        blink_timer--;
    }

    if (pwm_timer > 0) {
        pwm_timer--;
    }
}

ISR(INT0_vect)
{
    if (debounce_counter == 0) {
        mode_selector++;
        if (mode_selector > 2) {
            mode_selector = 0;
        }
        mode_changed = 1;
        debounce_counter = 50;
    }
}

void timer1_init(void)
{

    TCCR1 = (1 << CTC1) | (1 << CS12);
    OCR1C = 125 - 1;
    OCR1A = 125 - 1;
    TIMSK |= (1 << OCIE1A);
}

void pwm_init(void)
{
    TCCR0A = (1 << COM0A1) | (1 << COM0B1) | (1 << WGM01) | (1 << WGM00);
    TCCR0B = (1 << CS01) | (1 << CS00);
    OCR0A = 0;
    OCR0B = 255;
}

void pwm_disable(void)
{
    TCCR0A &= ~((1 << COM0A1) | (1 << COM0B1));
    PORTB &= ~(LED1 | LED2);
}

void pwm_setDutyCycle(uint8_t duty_led1, uint8_t duty_led2)
{
    if (duty_led1 == 0) {
        TCCR0A &= ~(1 << COM0A1);
        PORTB &= ~LED1;
    } else if (duty_led1 == 255) {
        TCCR0A &= ~(1 << COM0A1);
        PORTB |= LED1;
    } else {
        TCCR0A |= (1 << COM0A1);
    }
    OCR0A = duty_led1;

    if (duty_led2 == 0) {
        TCCR0A &= ~(1 << COM0B1);
        PORTB &= ~LED2;
    } else if (duty_led2 == 255) {
        TCCR0A &= ~(1 << COM0B1);
        PORTB |= LED2;
    } else {
        TCCR0A |= (1 << COM0B1);
    }
    OCR0B = duty_led2;
}

void mode_blink_update(void)
{
    if (blink_timer == 0) {
        blink_timer = 500;
        
        if (blink_state == 0) {
            PORTB |= LED1;
            PORTB &= ~LED2;
            blink_state = 1;
        } else {
            PORTB &= ~LED1;
            PORTB |= LED2;
            blink_state = 0;
        }
    }
}

void mode_pwm_update(void)
{
    if (pwm_timer == 0) {
        pwm_timer = 5;
        
        pwm_setDutyCycle(pwm_duty, 255 - pwm_duty);
        
        pwm_duty += pwm_direction;
        
        if (pwm_duty == 255) {
            pwm_direction = -1;
        } else if (pwm_duty == 0) {
            pwm_direction = 1;
        }
    }
}

int main(void)
{
    DDRB |= LED1 | LED2;
    DDRB &= ~BUTTON_1;
    PORTB |= BUTTON_1;
    PORTB &= ~(LED1 | LED2);

    MCUCR &= ~(1 << ISC00);
    MCUCR |= (1 << ISC01);
    GIMSK |= (1 << INT0);
    GIFR |= (1 << INTF0);

    timer1_init();
    
    sei();

    uint8_t current_mode = 0;
    
    while (1) {
        if (mode_changed) {
            mode_changed = 0;
            current_mode = mode_selector;

            pwm_disable();
            blink_state = 0;
            blink_timer = 0;
            pwm_duty = 0;
            pwm_direction = 1;
            pwm_timer = 0;

            if (current_mode == 1) {
                pwm_init();
            }
        }
        
        switch (current_mode) {
            case 0:
                mode_blink_update();
                break;
            
            case 1:
                mode_pwm_update();
                break;
            case 2:
                PORTB |= LED1;
                PORTB |= LED2;
                break;
            
        }
    }
    
    return 0;
}

## Commit log (part)

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2026-06-14 Readme added
