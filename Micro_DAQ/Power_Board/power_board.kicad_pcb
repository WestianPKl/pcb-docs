# Repository WestianPKl/pcb-docs

File README.md:

# PCB Manager — Board Collection

A collection of custom PCB designs created in **KiCAD**, centered around the **Raspberry Pi Pico (RP2040)** platform. Each board is a standalone module that connects to the Main Board and extends its functionality via I2C, SPI, or UART.

**Author:** Piotr Kłyś  
**Tool:** KiCAD 8.x  
**Firmware:** MicroPython (Pico boards), AVR-GCC (ATmega boards)

---

## Boards Overview

| Board | Version | Interface | IC / Description |
|---|---|---|---|
| [Main_Board](#main_board) | 1.0 / 1.1 / 1.2a | — | Raspberry Pi Pico test & integration board |
| [CAN_Board](#can_board) | 1.0 | SPI | MCP2515 — CAN bus controller |
| [EEPROM_Board](#eeprom_board) | 1.0 | I2C | M24C32 — 32 Kbit EEPROM |
| [GPIO_Board](#gpio_board) | 1.0 | I2C | MCP23017 — 16-bit GPIO expander |
| [INA_Board](#ina_board) | 1.0 | I2C | INA226 — voltage / current / power monitor |
| [RTC_Board](#rtc_board) | 1.0 | I2C | PCF8563T — real-time clock |
| [Relay_Board](#relay_board) | 1.0 | GPIO | 2-channel relay module |
| [Modbus_Board](#modbus_board) | 1.0 | UART | RS-485 / Modbus RTU |
| [Power_Board](#power_board) | 1.0 | — | DC power supply module |
| [MOSFET_Board](#mosfet_board) | 1.0 | GPIO | High-side / low-side MOSFET switch |
| [Amplifier_Board](#amplifier_board) | — | Analog | Signal amplifier |
| [ATMega_Board](#atmega_board) | 1.0 | — | ATmega (through-hole) development board |
| [ATMegaSMD_Board](#atmegasmd_board) | 1.0 | — | ATmega (SMD) development board |
| [Tree_Board](#tree_board) | — | — | AVR LED Christmas tree |
| [IoT_Logger_B_1.0](#iot_logger_b) | 1.0 | — | IoT data logger revision B |
| [IoT_Logger_C_1.0](#iot_logger_c) | 1.0 | — | IoT data logger revision C |
| [Pico_TH_Logger_SMD_PCF8563T_2.1](#pico_th_logger) | 2.1 | I2C | Pico temp/humidity logger with RTC |
| [Pico_TH_Logger_Relay_SMD_PCF8563T_2.1](#pico_th_logger_relay) | 2.1 | I2C | Pico temp/humidity logger with RTC + relay |

---

## Board Details

### Main_Board

The central development and integration board built around the **Raspberry Pi Pico**. Used to test all peripheral modules in the collection.

**Features:**
- RGB LED (PWM)
- 2× status LEDs (PWM)
- Buzzer (PWM)
- 2× push buttons
- ADC input with 100 kΩ / 200 kΩ voltage divider
- Connectors for all expansion boards (I2C, SPI, CAN, EEPROM, GPIO, INA, RTC, Relay)
- Optional multi-threaded test runner (`_thread`)

**Firmware:** `Main_Board/Code/main.py`

---

### CAN_Board

CAN bus communication module using the **MCP2515** controller over SPI.

**Features:**
- SPI interface to Pico
- Standard CAN 2.0 frame support
- Loopback, sniffer, and master/slave test scripts

**Firmware:** `CAN_Board/Code/`
- `can_mcp2515.py` — low-level MCP2515 driver
- `can_communication.py` — higher-level protocol
- `hello.py`, `loopback.py`, `sniffer.py`, `can_slave.py`, `can_test.py` — examples

---

### EEPROM_Board

Non-volatile storage expansion using the **M24C32** (32 Kbit / 4 KB) I2C EEPROM.

**Firmware:** `EEPROM_Board/Code/eeprom_m24c32.py`

---

### GPIO_Board

16-bit I2C GPIO expander using the **MCP23017**, providing two 8-bit ports (Port A / Port B) with interrupt support.

**Firmware:** `GPIO_Board/Code/expander_mpc23017.py`

---

### INA_Board

High-side power monitoring using the **INA226** — measures bus voltage, shunt voltage, current, and power via I2C.

**Default configuration:**
- Shunt resistor: 100 mΩ
- Max current: 3.2 A
- Alert pin supported

**Firmware:** `INA_Board/Code/measurement_ina226.py`

---

### RTC_Board

Real-time clock module using the **PCF8563T** via I2C. Provides timekeeping, alarm, and 1 Hz clock output.

**Features:**
- Date / time read and write
- Alarm support
- 1 Hz CLKOUT output
- Battery backup pin

**Firmware:** `RTC_Board/Code/rtc_pcf8563.py`

---

### Relay_Board

2-channel relay board controlled via GPIO from the Pico.

---

### Modbus_Board

RS-485 transceiver board enabling **Modbus RTU** communication over UART.

---

### Power_Board

DC power supply module — voltage regulation and distribution for the board ecosystem.

---

### MOSFET_Board

MOSFET-based switching board for controlling higher-power loads from Pico GPIO.

---

### Amplifier_Board

Analog signal amplifier module.

---

### ATMega_Board

Through-hole **ATmega** development board — classic DIP package, ISP programming header.

---

### ATMegaSMD_Board

SMD variant of the ATmega development board — compact form factor.

---

### Tree_Board

AVR-based LED Christmas tree — decorative board with animated LED patterns.

**Firmware:** `Tree_Board/TreeCode/main.c` (AVR-GCC)  
**Gerbers / renders:** `Tree_Board/PROD/`

---

### IoT_Logger_B

IoT data logger — revision B.

---

### IoT_Logger_C

IoT data logger — revision C. Improved layout over revision B.

---

### Pico_TH_Logger_SMD_PCF8563T_2.1

Compact SMD temperature and humidity logger based on Raspberry Pi Pico with a **PCF8563T** RTC for timestamped logging.

---

### Pico_TH_Logger_Relay_SMD_PCF8563T_2.1

Extended version of the TH Logger adding a **relay output** for threshold-based control (e.g. ventilation, heating).

---

## Repository Structure

```
pcb-docs/
├── <BoardName>/
│   ├── <BoardName>.kicad_pro      # KiCAD project
│   ├── <BoardName>.kicad_sch      # Schematic
│   ├── <BoardName>.kicad_pcb      # PCB layout
│   ├── Code/                      # MicroPython / C firmware
│   └── PROD/                      # Gerbers, renders, BOM exports
├── Boards_BOM.ods                 # Combined Bill of Materials
└── README.md
```

Each board may contain multiple revision subdirectories (e.g. `1.0/`, `1.1/`).

---

## Getting Started

### Requirements

- **KiCAD 8.x** — to open schematics and PCB layouts
- **Thonny** or **mpremote** — to flash MicroPython firmware to Pico
- **AVR-GCC + avrdude** — for Tree_Board / ATmega boards

### Running firmware on Pico

1. Flash [MicroPython](https://micropython.org/download/RPI_PICO/) to your Raspberry Pi Pico.
2. Copy the relevant driver file(s) from `<BoardName>/Code/` to the Pico filesystem.
3. Run or import the module from the REPL or `main.py`.

```python
# Example — INA226 power monitor
from machine import I2C, Pin
from measurement_ina226 import MEASUREMENT_INA226

i2c = I2C(0, sda=Pin(4), scl=Pin(5))
ina = MEASUREMENT_INA226(i2c, r_shunt_ohm=0.1, max_current=3.2)
print(ina.read_voltage(), ina.read_current(), ina.read_power())
```

---

## Bill of Materials

A combined BOM for all boards is available in [`Boards_BOM.ods`](Boards_BOM.ods) (OpenDocument Spreadsheet).

---

## License

This project is licensed under the [CERN Open Hardware Licence v2 - Permissive (CERN-OHL-P)](https://ohwr.org/cern_ohl_p_v2.txt).

You are free to use, modify, and manufacture these designs. Attribution appreciated.

## KiCad design Micro_DAQ/Power_Board/power_board.kicad_pcb

Parts:
C1: 4.7uF; C_0603_1608Metric
C2, C3, C4, C5, C6, C9, C10, C26, C27, C28, C29, C30, C31, C32: 100nF; C_0603_1608Metric
C7, C14, C16, C17, C20: 100nF; C_0805_2012Metric
C8, C12: 10uF; C_1206_3216Metric
C11, C13, C18: 1uF; C_0805_2012Metric
C15: 100uF NC; C_0805_2012Metric
C19: 2.2uF; C_0603_1608Metric
C21, C22, C23, C24: 22uF; C_1206_3216Metric
C25: 1uF; C_0603_1608Metric
D1: SMBJ15A; D_SMB
D2: SMAJ15A; D_SMA
F1: 3A; Fuse_2920_7451Metric
IC1: STM32C542CCT6; QFP50P900X900X160-48N; Manufacturer_Part_Number STM32C562CET6
IC2: MCP2562FD-E_SN; SOIC127P600X175-8N; Manufacturer_Part_Number MCP2562FD-E/SN; Mouser Part Number 579-MCP2562FD-E/SN
IC3: INA226AIDGSR; SOP50P490X110-10N; Manufacturer_Part_Number INA226AIDGSR; Mouser Part Number 595-INA226AIDGSR
J1: Supply; BarrelJack_GCT_DCJ200-10-A_Horizontal
J2: PWR; PinSocket_2x15_P2.54mm_Vertical
J3: LED; PinSocket_2x04_P2.54mm_Vertical
J4: JTAG; PinHeader_2x05_P1.27mm_Vertical
L1: DJNR8040-4R7; DJNR8040680; Manufacturer_Part_Number DJNR8040-680
L2: SDR0805-3R9ML; SDR08053R9ML; Manufacturer_Part_Number SDR0805-3R9ML; Mouser Part Number 652-SDR0805-3R9ML
Q1: SI7121ADN-T1-GE3; SQS850ENT1_GE3; Manufacturer_Part_Number SI7121ADN-T1-GE3; Mouser Part Number 78-SI7121ADN-T1-GE3
R1, R2, R3, R15, R18, R26, R27: 1kR; R_0603_1608Metric
R4: 3k3R; R_0603_1608Metric
R5, R6, R7: 10kR; R_0603_1608Metric
R8: 100kR; R_1206_3216Metric
R9, R11: 180kR; R_0603_1608Metric
R10, R12, R14, R17: 27kR; R_0603_1608Metric
R13: 68kR; R_0603_1608Metric
R16: 33kR; R_0603_1608Metric
R19: R_SHUNT; R_2512_6332Metric
R20, R21, R22: 10R; R_0603_1608Metric
R23, R24, R25: 4k7R; R_0603_1608Metric
U1: TLV75533PDBV; SOT-23-5
U2: AP63205WU; TSOT-23-6
U3: AP63203WU; TSOT-23-6

Connections:
+3.3V_AUX: C23.2, J2.24, J2.26, J2.28, J2.30, L2.2, R16.1, U3.1 (FB)
+3.3V_MCU: C1.1, C2.1, C3.1, C4.1, C6.1, C10.2, C18.2, C20.2, C25.1, C26.1, IC1.9 (VREF+), IC1.24 (VDD_1), IC1.36 (VDD_2), IC1.48 (VDD_3), IC2.5 (VIO), IC3.6 (VS), J4.1 (VTref), R5.1, R23.2, R24.2, R25.1, U1.5 (OUT)
+5V: C9.2, C11.2, C14.2, C21.2, IC2.3 (VDD), J2.16, J2.18, J2.20, J2.22, L1.2, R13.1, U1.1 (IN), U1.3 (EN), U2.1 (FB)
+12V: C8.2, C12.2, J2.2, J2.4, J2.6, J2.8, J2.10, J2.12, J2.14, R11.1, R19.2, R22.1, U2.2 (EN), U2.3 (IN), U3.2 (EN), U3.3 (IN)
+12V_BUS: C7.2, C13.2, C15.2, D1.1 (K), D2.1 (A1), Q1.1 (S_1), Q1.2 (S_2), Q1.3 (S_3), R19.1, R21.1
/5V_ADC: C31.2, IC1.12 (PA2), R26.2
/12V_ADC: C30.2, IC1.11 (PA1), R18.2
/AUX_ADC: C32.2, IC1.13 (PA3), R27.2
/Alert0: IC1.14 (PA4), IC3.3 (ALERT), R23.1
/BOOT0: IC1.44 (PH2-BOOT0), R6.1
/CAN1_H: IC2.7 (CANH), J2.21
/CAN1_L: IC2.6 (CANL), J2.23
/FAULT_PWR: IC1.27 (PB14), J2.25
/FDCAN1_RX: IC1.32 (PA11), IC2.4 (RXD)
/FDCAN1_TX: IC1.33 (PA12), IC2.1 (TXD)
/I2C1_SCL: IC1.39 (PB3), IC3.5 (SCL), R25.2
/I2C1_SDA: IC1.40 (PB4), IC3.4 (SDA), R24.1
/LED1: IC1.18 (PB0), J3.3
/LED2: IC1.19 (PB1), J3.7
/LED3: IC1.20 (PB2), J3.8
/NRST: C5.2, IC1.7 (NRST), J4.10 (~RESET), R5.2
/PA5: IC1.15 (PA5)
/PA8: IC1.29 (PA8)
/PA9: IC1.30 (PA9)
/PA10: IC1.31 (PA10)
/PA15: IC1.38 (PA15)
/PB5: IC1.41 (PB5)
/PB6: IC1.42 (PB6)
/PB7: IC1.43 (PB7)
/PB9: IC1.46 (PB9)
/PB10: IC1.21 (PB10)
/PB12: IC1.25 (PB12)
/PB13: IC1.26 (PB13)
/PB15: IC1.28 (PB15)
/PC13: IC1.2 (PC13)
/PC14: IC1.3 (PC14-OSC32_IN)
/PC15: IC1.4 (PC15-OSC32_OUT)
/PE2: IC1.1 (PE2)
/PH0: IC1.5 (PH0-OSC_IN)
/PH1: IC1.6 (PH1-OSC_OUT)
/STBY: IC1.45 (PB8), IC2.8 (STBY), R7.1
/SWCLK: IC1.37 (PA14), J4.4 (SWCLK/TCK)
/SWDIO: IC1.34 (PA13), J4.2 (SWDIO/TMS)
/USART1_RX: IC1.17 (PA7), J2.27
/USART1_TX: IC1.16 (PA6), J2.29
/VBUS0: C28.1, IC3.9 (IN-), R20.1, R22.2
/VIN_ADC: C29.2, IC1.10 (PA0), R15.2
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.2, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C18.1, C19.1, C20.1, C22.1, C24.1, C25.2, C26.2, C27.1, C29.1, C30.1, C31.1, C32.1, D1.2 (A), IC1.8 (VREF-), IC1.23 (VSS_1), IC1.35 (VSS_2), IC1.47 (VSS_3), IC2.2 (VSS), IC3.1 (A1), IC3.2 (A0), IC3.7 (GND), J1.2, J1.3, J2.1, J2.3, J2.5, J2.7, J2.9, J2.11, J2.13, J2.15, J2.17, J2.19, J4.3 (GND), J4.5 (GND), J4.9 (GNDDetect), R1.2, R2.2, R3.2, R4.2, R6.2, R7.2, R8.2, R10.2, R12.2, R14.2, R17.2, U1.2 (GND), U2.4 (GND), U3.4 (GND)
unnamed: C21.1, C22.2
unnamed: C23.1, C24.2
unnamed: D2.2 (A2), Q1.4 (G), R8.1
unnamed: C19.2, IC1.22 (VCAP)
unnamed: C28.2, IC3.10 (IN+), R21.2
unnamed: C27.2, IC3.8 (VBUS), R20.2
unnamed: J3.1, R1.1
unnamed: J3.2, R4.1
unnamed: J3.5, R2.1
unnamed: J3.6, R3.1
unnamed: F1.2, Q1.5 (D_1), Q1.6 (D_2), Q1.7 (D_3), Q1.8 (D_4), Q1.9 (D_5), Q1.10 (D_6), Q1.11 (D_7)
unnamed: R9.2, R10.1, R15.1
unnamed: R11.2, R12.1, R18.1
unnamed: R13.2, R14.1, R26.1
unnamed: R16.2, R17.1, R27.1
unnamed: C16.1, U2.6 (BST)
unnamed: C16.2, L1.1, U2.5 (SW)
unnamed: C17.1, U3.6 (BST)
unnamed: C17.2, L2.1, U3.5 (SW)
VIN: F1.1, J1.1, J3.4, R9.1

Board: 2 copper layers, 100.0 x 80.0 mm, 75 parts (0 on the bottom side), 49 nets.

## KiCad design Micro_DAQ/Controller_Board/controller_board.kicad_pcb

Board: 2 copper layers, 100.0 x 80.0 mm, 114 parts (0 on the bottom side), 79 nets.

Parts:
C1: 4.7uF; C_0603_1608Metric
C2, C3, C4, C5, C6, C8, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C44, C46, C47: 100nF; C_0603_1608Metric
C7: 1nF; C_0603_1608Metric
C9, C45: 1uF; C_0603_1608Metric
C10, C11: 12pF; C_0603_1608Metric
C12, C13: 20pF; C_0603_1608Metric
C14, C15: 2.2uF; C_0603_1608Metric
C40: 100nF; C_0805_2012Metric
C41: 82pF; C_0805_2012Metric
C42, C43: 4.7uF; C_0805_2012Metric
D1, D2, D3: TPD2E009DBZR; SOT-23-3
D4, D5: TGL34-36A; D_MiniMELF
D6: SS16; D_SMA
FB1: CBM03YTAG601-1; L_0603_1608Metric
IC1: MCP2562FD-E_SN; SOIC127P600X175-8N
IC2: TLV3502AID; SOIC127P600X175-8N
IC3: DG408DY-E3; SOIC127P600X175-16N
J1: LED; PinSocket_2x04_P2.54mm_Vertical
J2: DS1037-37FNAKT74-0CC; DS103737FNAKT740CC
J3: JTAG; PinHeader_2x05_P1.27mm_Vertical
J4: PWR; PinSocket_2x15_P2.54mm_Vertical
L1: LQH43CN100K03L; L_1812_4532Metric
R1: 3k3R; R_0603_1608Metric
R2, R4, R5, R37: 1kR; R_0603_1608Metric
R3, R6, R7: 10kR; R_0603_1608Metric
R8, R11, R12, R13, R14, R15: 4k7R; R_0603_1608Metric
R9, R10, R16, R17, R18, R19, R20, R21, R25, R29: 330R; R_0603_1608Metric
R22, R24, R26, R28: 10R; R_0603_1608Metric
R23, R27: R_SHUNT; R_2512_6332Metric
R30: 357kR; R_0603_1608Metric
R31: 1MR; R_0603_1608Metric
R32: 13k3R; R_0603_1608Metric
R33: 3.3MR; R_0603_1608Metric
R34: 15kR; R_0603_1608Metric
R35: 33R; R_0603_1608Metric
R36: 1k2R; R_0603_1608Metric
U1: STM32H523CETx; LQFP-48_7x7mm_P0.5mm
U2, U3, U4, U5, U6, U7, U8, U9, U10, U11: INA226AIDGST; INA226AIDGSR
U12: LMR64010XMF; SOT-23-5
U13: OPA197xDBV; SOT-23-5
Y1: 3225-25M-SR; Crystal_SMD_3225-4Pin_3.2x2.5mm
Y2: 32.768K-CFPX217; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+3.3V_AUX: C1.1, C2.1, C3.1, C4.1, C5.1, C17.2, C18.1, C19.1, C22.1, C23.1, C26.1, C27.1, C30.1, C31.1, C34.1, C37.1, C44.2, FB1.1, IC1.5 (VIO), IC2.4 (-INB), IC2.8 (V+), J3.1 (VTref), J4.14, J4.16, R6.1, R8.2, R11.2, R12.2, R13.2, R14.2, R15.2, U1.1 (VBAT), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U2.6 (VS), U3.6 (VS), U4.1 (A1), U4.6 (VS), U5.1 (A1), U5.6 (VS), U6.2 (A0), U6.6 (VS), U7.2 (A0), U7.6 (VS), U8.1 (A1), U8.2 (A0), U8.6 (VS), U9.1 (A1), U9.2 (A0), U9.6 (VS), U10.6 (VS), U11.1 (A1), U11.6 (VS)
+5V: C16.2, IC1.3 (VDD), J4.10, J4.12
+12V: C43.2, J4.2, J4.4, J4.6, J4.8, L1.1, R31.2, U12.5 (VIN)
+34V: C40.2, C41.2, C42.2, C45.1, C46.1, D6.1 (K), IC3.13 (V+), R30.2, U13.5 (V+)
/BOOT0: R3.1, U1.44 (BOOT0)
/CAN1_H: IC1.7 (CANH), J4.25
/CAN1_L: IC1.6 (CANL), J4.27
/FAULT: J4.26, U1.27 (PB14)
/FDCAN1_RX: IC1.4 (RXD), U1.32 (PA11)
/FDCAN1_TX: IC1.1 (TXD), U1.33 (PA12)
/LED1: J1.3, U1.15 (PA5)
/LED2: J1.7, U1.16 (PA6)
/LED3: J1.8, U1.30 (PA9)
/LED4: J1.4, U1.31 (PA10)
/NRST: C6.2, J3.10 (~RESET), J4.24, R6.2, U1.7 (NRST)
/PC14: C12.2, U1.3 (PC14), Y2.1
/PC15: C13.2, U1.4 (PC15), Y2.2
/PH0: C10.2, U1.5 (PH0), Y1.3
/PH1: C11.2, U1.6 (PH1), Y1.1
/SLOT_ID0: J4.30, U1.25 (PB12)
/SLOT_ID1: J4.29, U1.26 (PB13)
/STBY: IC1.8 (STBY), R7.1, U1.45 (PB8)
/SWCLK: J3.4 (SWCLK/TCK), U1.37 (PA14(JTCK)
/SWDIO: J3.2 (SWDIO/TMS), U1.34 (PA13(JTMS)
/SYNC: J4.23, U1.17 (PA7)
/frequency_measurement/MUX_OUT: IC3.8 (D), R33.2, U13.3 (+)
DAC_OUT0: R37.1, U1.14 (PA4)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.2, C8.2, C9.2, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C36.2, C37.2, C39.2, C40.1, C42.1, C43.1, C44.1, C45.2, C46.2, C47.1, D1.3 (A), D2.3 (A), D3.3 (A), D4.2 (A), D5.2 (A), IC1.2 (VSS), IC2.3 (+IN_B), IC2.5 (V-), IC3.3 (V-), IC3.14 (GND), J2.20, J2.21, J2.22, J2.23, J2.24, J2.25, J2.26, J2.27, J2.28, J2.29, J2.30, J2.31, J2.34, J2.35, J2.36, J2.MH1, J2.MH2, J3.3 (GND), J3.5 (GND), J3.9 (GNDDetect), J4.1, J4.3, J4.5, J4.7, J4.9, J4.11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
I2C1_SCL: D1.2 (K), R11.1, U1.42 (PB6), U2.5 (SCL), U4.5 (SCL), U6.5 (SCL), U8.5 (SCL)
I2C1_SDA: D1.1 (K), R8.1, U1.43 (PB7), U2.4 (SDA), U4.4 (SDA), U6.4 (SDA), U8.4 (SDA)
I2C2_SCL: D2.2 (K), R13.1, U1.21 (PB10), U10.5 (SCL), U11.5 (SCL)
I2C2_SDA: D2.1 (K), R12.1, U1.39 (PB3(JTDO), U10.4 (SDA), U11.4 (SDA)
I2C3_SCL: D3.2 (K), R15.1, U1.29 (PA8), U3.5 (SCL), U5.5 (SCL), U7.5 (SCL), U9.5 (SCL)
I2C3_SDA: D3.1 (K), R14.1, U1.40 (PB4(NJTRST)), U3.4 (SDA), U5.4 (SDA), U7.4 (SDA), U9.4 (SDA)
IN0: IC3.4 (S1), J2.1, R9.1
IN1: IC3.5 (S2), J2.2, R16.1
IN2: IC3.6 (S3), J2.3, R18.1
IN3: IC3.7 (S4), J2.4, R20.1
IN4: IC3.12 (S5), J2.5, R10.1
IN5: IC3.11 (S6), J2.6, R17.1
IN6: IC3.10 (S7), J2.7, R19.1
IN7: IC3.9 (S8), J2.8, R21.1
INA0+: D4.1 (K), J2.12, J2.13, J2.14, R22.1, R23.1
INA0-: J2.9, J2.10, J2.11, R23.2, R24.1
INA1+: D5.1 (K), J2.18, J2.19, J2.37, R26.1, R27.1
INA1-: J2.15, J2.16, J2.17, R27.2, R28.1
MUX_A0: IC3.1 (A0), U1.18 (PB0)
MUX_A1: IC3.16 (A1), U1.19 (PB1)
MUX_A2: IC3.15 (A2), U1.20 (PB2)
MUX_EN: IC3.2 (EN), U1.41 (PB5)
unnamed: C14.2, U1.22 (VCAP)
unnamed: C15.2, U1.46 (VCAP)
unnamed: D6.2 (A), L1.2, U12.1 (SW)
unnamed: IC2.1 (+IN_A), R34.1, R36.2
unnamed: C47.2, IC2.2 (-IN_A), R37.2
unnamed: IC2.7 (OUT_A), R35.2
unnamed: J1.1, R4.1
unnamed: J1.2, R1.1
unnamed: J1.5, R5.1
unnamed: J1.6, R2.1
unnamed: C20.1, R9.2, U2.8 (Vbus)
unnamed: C21.1, R10.2, U3.8 (Vbus)
unnamed: C24.1, R16.2, U4.8 (Vbus)
unnamed: C25.1, R17.2, U5.8 (Vbus)
unnamed: C28.1, R18.2, U6.8 (Vbus)
unnamed: C29.1, R19.2, U7.8 (Vbus)
unnamed: C32.1, R20.2, U8.8 (Vbus)
unnamed: C33.1, R21.2, U9.8 (Vbus)
unnamed: C35.2, R22.2, U10.10 (Vin+)
unnamed: C35.1, R24.2, R25.2, U10.9 (Vin-)
unnamed: C38.2, R26.2, U11.10 (Vin+)
unnamed: C38.1, R28.2, R29.2, U11.9 (Vin-)
unnamed: R31.1, U12.4 (EN)
unnamed: C41.1, R30.1, R32.2, U12.3 (FB)
unnamed: R34.2, U13.1, U13.4 (-)
TIM_FREQ: R35.1, U1.10 (PA0)
VBUS0: C36.1, J2.32, R25.1, U10.8 (Vbus)
VBUS1: C39.1, J2.33, R29.1, U11.8 (Vbus)
VDDA: C7.1, C8.1, C9.1, FB1.2, U1.9 (VDDA)

## KiCad design Micro_DAQ/Communication_Board/communication_board.kicad_pcb

Parts:
C1: 4.7uF; C_0603_1608Metric
C2, C3, C4, C5, C6, C9, C10, C11, C12, C18, C20, C21, C22, C23, C24: 100nF; C_0603_1608Metric
C13: 4.7nF; C_0603_1608Metric
C14, C15: 12pF; C_0603_1608Metric
C19: 2.2uF; C_0603_1608Metric
C25: 68nF; C_0603_1608Metric
C26: 1nF; C_0603_1608Metric
D1: TPD2E009DBZR; SOT-23-3
D2, D3, D4: PESD3V3S2UT.215; SOT-23-3
D5: CDSOT23-SM712; SOT-23
D6: ESDCAN04; SOT-23
D7: ESDLIN1524BJ; D_SOD-323
D8, D9: SMBJ15CA-TR; DIONM5336X245N; Manufacturer_Part_Number SMBJ36CA; Mouser Part Number 512-SMBJ36CA
D10, D11, D12: 1N4148W; D_SOD-123
IC1: STM32C542CC; QFP50P900X900X160-48N; Manufacturer_Part_Number STM32C562CET6
IC2, IC6: MCP2562FD-E_SN; SOIC127P600X175-8N; Manufacturer_Part_Number MCP2562FD-E/SN; Mouser Part Number 579-MCP2562FD-E/SN
IC3: SN65HVD10DR; SOIC127P600X175-8N; Manufacturer_Part_Number SN65HVD10DR; Mouser Part Number 595-SN65HVD10DR
IC4: MAX3232EIDR; SOIC127P600X175-16N; Manufacturer_Part_Number MAX3232EIDR; Mouser Part Number 595-MAX3232EIDR
IC5: TJA1021T_20_C,118; SOIC127P600X175-8N; Manufacturer_Part_Number TJA1021T/20/C,118; Mouser Part Number 771-TJA1021T20C118
J2: PWR; PinSocket_2x15_P2.54mm_Vertical
J3: LED; PinSocket_2x04_P2.54mm_Vertical
J4: JTAG; PinHeader_2x05_P1.27mm_Vertical
J5: DS1037-37FNAKT74-0CC; DS103737FNAKT740CC; Manufacturer_Part_Number DS1037-37FNAKT74-0CC
K1, K2: 1-1462037-4; 114620374; Manufacturer_Part_Number 1-1462037-4
Q1, Q2: 2N7002; SOT-23
R1, R2, R3, R18: 1kR; R_0603_1608Metric
R4: 3k3R; R_0603_1608Metric
R5, R6, R7, R8, R13: 10kR; R_0603_1608Metric
R9, R10: 60.4R; R_0603_1608Metric
R11, R17: 100kR; R_0603_1608Metric
R12, R16: 100R; R_0603_1608Metric
R14: 120R; R_0603_1608Metric
R15: 4k7R; R_0603_1608Metric
R19: 0R Master; R_0603_1608Metric
Y1: 3225-25M-SR; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V_AUX: C1.1, C2.1, C3.1, C4.1, C6.1, C10.2, C12.2, C18.2, C20.2, IC1.9 (VREF+), IC1.24 (VDD_1), IC1.36 (VDD_2), IC1.48 (VDD_3), IC2.5 (VIO), IC3.8 (VCC), IC4.16 (VCC), IC6.5 (VIO), J2.14, J2.16, J4.1 (VTref), R5.1, R15.1
+5V: C9.2, C11.2, D10.1 (K), D11.1 (K), IC2.3 (VDD), IC6.3 (VDD), J2.10, J2.12, K1.1 (+), K2.1 (+)
+12V: C25.2, D12.2 (A), IC5.3 (WAKE_N), IC5.7 (VBAT), J2.2, J2.4, J2.6, J2.8
/BOOT0: IC1.44 (PH2-BOOT0), R6.1
/C1+: C24.2, IC4.1 (C1+)
/C1-: C24.1, IC4.3 (C1-)
/C2+: C22.2, IC4.4 (C2+)
/C2-: C22.1, IC4.5 (C2-)
/CAN1_H: IC2.7 (CANH), J2.25
/CAN1_L: IC2.6 (CANL), J2.27
/CAN2_H: D6.1 (A1), IC6.7 (CANH), J5.9, K1.3 (COM_1)
/CAN2_L: D6.2 (A2), IC6.6 (CANL), J5.10, K1.6 (COM_2)
/CAN2_STBY: IC1.1 (PE2), IC6.8 (STBY), R8.1
/CAN2_TERM_EN: IC1.2 (PC13), R12.1
/FAULT: IC1.27 (PB14), J2.26
/FDCAN1_RX: IC1.32 (PA11), IC2.4 (RXD)
/FDCAN1_TX: IC1.33 (PA12), IC2.1 (TXD)
/FDCAN2_RX: IC1.39 (PB3), IC6.4 (RXD)
/FDCAN2_TX: IC1.40 (PB4), IC6.1 (TXD)
/I2C1_SCL: D1.2 (K), IC1.29 (PA8), J5.7
/I2C1_SDA: D1.1 (K), IC1.43 (PB7), J5.8
/LED1: IC1.20 (PB2), J3.3
/LED2: IC1.21 (PB10), J3.7
/LED3: IC1.12 (PA2), J3.8
/LED4: IC1.13 (PA3), J3.4
/LIN: C26.2, D7.1 (A1), IC5.6 (LIN), J5.19, R19.2
/LIN_SLEEP_N: IC1.38 (PA15), IC5.2 (SLP_N)
/NRST: C5.2, IC1.7 (NRST), J2.24, J4.10 (~RESET), R5.2
/PC15: IC1.4 (PC15-OSC32_OUT)
/PH0: C14.2, IC1.5 (PH0-OSC_IN), Y1.3
/PH1: C15.2, IC1.6 (PH1-OSC_OUT), Y1.1
/RES0_0: J2.17
/RES1_0: J2.19
/RES2_0: J2.21
/RES3_0: J2.18
/RES4_0: J2.20
/RES5_0: J2.22
/RS232_RX: D8.1, IC4.13 (RIN1), J5.12
/RS232_TX: D9.1, IC4.14 (DOUT1), J5.11
/RS485_A: D5.2 (A2), IC3.6 (A), J5.13, K2.6 (COM_2)
/RS485_B: D5.1 (A1), IC3.7 (B), J5.14, K2.3 (COM_1)
/RS485_DIR: IC1.46 (PB9), IC3.2 (~RE), IC3.3 (DE), R13.1
/RS485_TERM_EN: IC1.3 (PC14-OSC32_IN), R16.1
/SLOT_ID0: IC1.25 (PB12), J2.30
/SLOT_ID1: IC1.26 (PB13), J2.29
/SPI1_MISO: D4.1 (K), IC1.16 (PA6), J5.4
/SPI1_MOSI: D4.2 (K), IC1.17 (PA7), J5.3
/SPI1_NSS: D3.1 (K), IC1.14 (PA4), J5.6
/SPI1_SCK: D3.2 (K), IC1.15 (PA5), J5.5
/STBY: IC1.45 (PB8), IC2.8 (STBY), R7.1
/SWCLK: IC1.37 (PA14), J4.4 (SWCLK/TCK)
/SWDIO: IC1.34 (PA13), J4.2 (SWDIO/TMS)
/SYNC: IC1.28 (PB15), J2.23
/UART4_RX: IC1.11 (PA1), IC4.12 (ROUT1)
/UART4_TX: IC1.10 (PA0), IC4.11 (DIN1)
/UART5_RX: D2.2 (K), IC1.41 (PB5), J5.1
/UART5_TX: D2.1 (K), IC1.42 (PB6), J5.2
/USART1_RX: IC1.31 (PA10), IC5.1 (RXD), R15.2
/USART1_TX: IC1.30 (PA9), IC5.4 (TXD)
/USART2_RX: IC1.19 (PB1), IC3.1 (R)
/USART2_TX: IC1.18 (PB0), IC3.4 (D)
/V+: C21.2, IC4.2 (V+)
/V-: C23.2, IC4.6 (V-)
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.2, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C18.1, C19.1, C20.1, C21.1, C23.1, C25.1, C26.1, D1.3 (A), D2.3 (A), D3.3 (A), D4.3 (A), D5.3 (common), D6.3 (common), D7.2 (A2), D8.2, D9.2, IC1.8 (VREF-), IC1.23 (VSS_1), IC1.35 (VSS_2), IC1.47 (VSS_3), IC2.2 (VSS), IC3.5 (GND), IC4.15 (GND), IC5.5 (GND), IC6.2 (VSS), J2.1, J2.3, J2.5, J2.7, J2.9, J2.11, J2.13, J2.15, J2.28, J4.3 (GND), J4.5 (GND), J4.9 (GNDDetect), J5.15, J5.16, J5.17, J5.18, J5.20, J5.21, J5.22, J5.23, J5.24, J5.25, J5.26, J5.27, J5.28, J5.29, J5.30, J5.31, J5.32, J5.33, J5.34, J5.35, J5.36, J5.37, J5.MH1, J5.MH2, Q1.2 (S), Q2.2 (S), R1.2, R2.2, R3.2, R4.2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
unnamed: C13.2, R9.2, R10.1
unnamed: D10.2 (A), K1.8 (-), Q1.3 (D)
unnamed: D11.2 (A), K2.8 (-), Q2.3 (D)
unnamed: D12.1 (K), R18.1
unnamed: C19.2, IC1.22 (VCAP)
unnamed: J3.1, R1.1
unnamed: J3.2, R4.1
unnamed: J3.5, R2.1
unnamed: J3.6, R3.1
unnamed: K1.4 (NO_1), R10.2
unnamed: K1.5 (NO_2), R9.1
unnamed: K2.4 (NO_1), R14.2
unnamed: K2.5 (NO_2), R14.1
unnamed: Q1.1 (G), R11.1, R12.2
unnamed: Q2.1 (G), R16.2, R17.1
unnamed: R18.2, R19.1

Board: 2 copper layers, 100.0 x 80.0 mm, 68 parts (0 on the bottom side), 73 nets.
